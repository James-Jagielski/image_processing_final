v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/madvlsi/MADVLSI/Miniproject2/CSRL_Latch.sym} 0 0 0 0 {name=X1}
C {devices/ipin.sym} -50 -20 0 0 {name=p1 lab=D}
C {devices/ipin.sym} -50 20 0 0 {name=p2 lab=Dn
}
C {devices/iopin.sym} 20 60 1 0 {name=p3 lab=CLK}
C {devices/iopin.sym} -20 60 1 0 {name=p4 lab=GND}
C {devices/iopin.sym} 0 -60 3 0 {name=p5 lab=VDD}
C {devices/opin.sym} 50 -20 0 0 {name=p6 lab=Q}
C {devices/opin.sym} 50 20 0 0 {name=p7 lab=Qn}
